# IAR project ampm_gprs.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xB ST STM32F103xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: STM32F10X_MD; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..\..\driver\STM32F10x_StdPeriph_Driver\inc; ..\..\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\inc; ..\..\ampm_lib; ..\..\driver; ..\..\ampm_lib\gsm; ..\..\driver\ampm\stm32; ..\..\ampm_lib\db; ..\..\ampm_lib\flash_mem; ..\..\ampm_lib\accelerometer\lis3dh; ..\..\ampm_lib\accelerometer\mma7660; ..\..\ampm_lib\accelerometer; ..\..\ampm_lib\PPP; ..\..\ampm_lib\uip; ..\..\ampm_lib\uip-ppp-lib; ..\..\ampm_lib\gsm\sms; ..\..\ampm_lib\FATFS; ..\..\ampm_lib\flash_mem; ..\..\ampm_lib\common
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ampm_gprs.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: D:\AMPM\SVN\VT1000\trunk\firmware\gt1025\build\iar\icfFile\stm32f103x8_FWNonBoot.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: ampm_gprs.bin
  group accel
    ../../ampm_lib/accelerometer/mma7660/: mma7660.c
  group CMSIS
    ../../CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group common_lib/ampm_lib
    ../../ampm_lib/lib/: data_cmp.c encoding.c list.c packet_queue.c protocol.c ringbuf.c sparser.c sys_tick.c sys_time.c tick.c
  group common_lib/uip-ppp/ppp
    ../../ampm_lib/PPP/: fcs.c ppp.c xtea.c
  group common_lib/uip-ppp/uip
    ../../ampm_lib/uip/: resolv.c resolver.c timer.c uip.c uip_ppp.c
  group db
    ../../ampm_lib/db/: db.c
    ../../ampm_lib/flash_mem/: sst25.c
  group driver
    ../../driver/ampm/stm32/: exti.c i2c.c low_power_mode.c rtc.c spi.c uart1.c uart2.c uart3.c
    ../../driver/STM32F10x_StdPeriph_Driver/src/: stm32f10x_flash.c stm32f10x_iwdg.c stm32f10x_rcc.c
  group gps
    ../../ampm_lib/gps/: gps.c
  group gsm_task
    ../../ampm_lib/gsm/: at_cmd_call_parser.c at_cmd_common_parser.c at_cmd_sms_parser.c at_command_parser.c at_gsm_task.c at_send_cmd_task.c gsm_hwr.c modem.c
    ../../ampm_lib/common/: comm.c
    ../../ampm_lib/gsm/sms/: pdu.c
  group icfFile
    icfFile/: stm32f103x8_FWNonBoot.icf stm32f103x8_FWWithBoot.icf
  group main
    ../../src/: accelerometer_task.c adc_task.c alarm_task.c app_config_task.c call_task.c database_app.c firmware_task.c hw_config.c led.c main.c reporter.c sms_server.c sms_task.c system_config.c tcp_ip_task.c tracker.c uart_config_task.c
  group startup
    ../../CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_md.s
