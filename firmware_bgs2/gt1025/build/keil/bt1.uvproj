# Keil uVision project bt1.uvproj, settings and files
target GT1025_RELEASE (ARM-ADS)
  device: STM32F103CB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: gt1025_V0 +hex
  AfterMake: fromelf --bin --output .\output\gt1025_V0.bin .\flash\gt1025_V0.axf
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\..\driver\STM32F10x_StdPeriph_Driver\inc;..\..\CMSIS\CM3\CoreSupport;..\..\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\inc;..\..\ampm_lib;..\..\driver;..\..\ampm_lib\gsm;..\..\driver\ampm\stm32;..\..\ampm_lib\db;..\..\ampm_lib\flash_mem;..\..\ampm_lib\accelerometer\lis3dh;..\..\ampm_lib\accelerometer\mma7660;..\..\ampm_lib\accelerometer;..\..\ampm_lib\PPP;..\..\ampm_lib\uip;..\..\ampm_lib\uip-ppp-lib;..\..\ampm_lib\gsm\sms;..\..\ampm_lib\FATFS;..\..\ampm_lib\flash_mem;..\..\ampm_lib\common
  library: MicroLIB
  memory RVCT4: ROM 0x8002800 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group main
    ../../src/: main.c system_config.c hw_config.c tracker.c adc_task.c sms_task.c call_task.c app_config_task.c uart_config_task.c database_app.c alarm_task.c led.c reporter.c firmware_task.c tcp_ip_task.c accelerometer_task.c
  group Startup
    ../../CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group CMSIS
    ../../CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group driver
    ../../ampm_lib/lib/: tick.c
    ../../driver/STM32F10x_StdPeriph_Driver/src/: stm32f10x_flash.c stm32f10x_iwdg.c stm32f10x_gpio.c stm32f10x_dma.c stm32f10x_dac.c stm32f10x_adc.c stm32f10x_rcc.c
    ../../driver/ampm/stm32/: uart1.c uart2.c uart3.c i2c.c spi.c low_power_mode.c rtc.c exti.c
  group common_lib
    ../../ampm_lib/uip/: resolver.c resolv.c timer.c uip.c uip_ppp.c
    ../../ampm_lib/PPP/: fcs.c ppp.c xtea.c
    ../../ampm_lib/lib/: m_time.c sys_time.c data_cmp.c encoding.c list.c packet_queue.c protocol.c ringbuf.c sparser.c sys_tick.c
  group gsm_task
    ../../ampm_lib/gsm/: gsm_hwr.c at_cmd_call_parser.c at_cmd_common_parser.c at_cmd_sms_parser.c at_command_parser.c at_gsm_task.c at_send_cmd_task.c modem.c
    ../../ampm_lib/gsm/sms/: pdu.c
    ../../ampm_lib/gsm/keil/Flash/: ampm_gsm.lib
    ../../ampm_lib/common/: comm.c
  group gps
    ../../ampm_lib/gps/keil/Output/: gps_lib.lib
    ../../ampm_lib/gps/: gps.c
  group db
    ../../ampm_lib/db/: db.c
    ../../ampm_lib/flash_mem/: sst25.c
  group accelerometer
    ../../ampm_lib/accelerometer/mma7660/: mma7660.c
  group note
    ../../../: note.txt
    ./output/: fw_version.txt
target GT1025_DEBUG (ARM-ADS)
  device: STM32F103CB STMicroelectronics
  cpu: as above
  output: gt1025_V0 +hex
  AfterMake: fromelf --bin --output .\debug\output\gt1025_V0.bin .\debug\gt1025_V0.axf
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER,DEBUG_MODE
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8002800 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
