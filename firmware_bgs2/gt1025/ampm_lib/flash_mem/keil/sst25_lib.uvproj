# Keil uVision project sst25_lib.uvproj, settings and files
target sst25_lib (ARM-ADS)
  device: STM32F101RC STMicroelectronics
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: sst25_lib (library)
  c flags: Optim=1
  c define: STM32F10X_HD
  c include: ..\..\flash_mem;..\..\..\driver\ampm\stm32
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group sst25
    ../: sst25.c
