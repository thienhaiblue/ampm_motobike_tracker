# Keil uVision project gps_lib.uvproj, settings and files
target gps_lib (ARM-ADS)
  device: STM32F101RC STMicroelectronics
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: gps_lib (library)
  c flags: Optim=1
  c include: ..\..\..\ampm_lib
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group gps
    ../: gps.c
